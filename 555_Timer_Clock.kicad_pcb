# Repository elaizajaena/KiCad_555_Timer_Clock_demo2

## KiCad design 555_Timer_Clock.kicad_pcb

Board: 2 copper layers, 39.0 x 25.0 mm, 16 parts (0 on the bottom side), 8 nets.

Parts:
C1: 0.01uF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C2: 470uF; CP_Elec_5x5.4
D1: LED; LED_D5.0mm
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: +5V; Terminal_Block_5mm
J2: CLK_Out; PinHeader_1x02_P2.54mm_Vertical
R1, R3, R4: 10K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2: 470; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1: Trigger; slide_switch_2.54mm
SW2: RST; tact_switch_5mm
U1: ICM7555xB; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/+5V: J1.1, R1.2, R3.2, R4.2, U1.8 (VCC)
/CLK_Out: D1.2 (A), J2.1, U1.3 (OUT)
/RST: R3.1, SW2.1, U1.4 (~RST)
/Trigger: R1.1, SW1.1 (A), U1.2 (TRIG)
GND: C1.2, C2.2, J1.2, J2.2, R2.1, SW1.2 (B), SW2.2, U1.1 (GND)
unnamed: D1.1 (K), R2.2
unnamed: C1.1, U1.5 (CONT)
unnamed: C2.1, R4.1, U1.6 (THRES), U1.7 (DISCH)

## Commit log

2026-04-10 commit on main
